SUMMARY = "Base class for DAC Images with cujo agent support"

inherit dac-image-base
